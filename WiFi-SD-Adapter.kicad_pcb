# Repository MMMZZZZ/WiFi-SD-Adapter

File README.md:

# WiFi SD Adapter

## Description

microSD to SD adapter with an ESP32-C3 "inbetween". It allows wireless access to the microSD card without removing the SD card from its slot. It does this with two bidirectional bus switches that disconnect the microSD card from the host and connect it to the ESP32 for the duration of the wireless access. 

Includes a single-sided USB C connector for programming. Might only work on a USB A host port though because it's single-sided. The single-sided is necessary to not become too thick for a USB C connector. 

Gerbers, [iBOM](https://htmlpreview.github.io/?https://github.com/MMMZZZZ/WiFi-SD-Adapter/blob/main/Exported/WiFi-SD-Adapter-iBom.html), etc. can be found in the [Exported](/Exported) folder. 

## Pics

|  |  |
|--|--|

|  |  |
|--|--|

## License

This project uses third-party libraries for parts and footprints (all located in the [Mouser-Parts](/Mouser-Parts) folder) to which the following licensing information may not apply. 

Copyright Max Zuidberg 2023.

This source describes Open Hardware and is licensed under the CERN-OHL-W v2 or later.

You may redistribute and modify this documentation and make products using it under the terms of the CERN-OHL-W v2 (https:/cern.ch/cern-ohl). This documentation is distributed WITHOUT ANY EXPRESS OR IMPLIED WARRANTY, INCLUDING OF MERCHANTABILITY, SATISFACTORY QUALITY AND FITNESS FOR A PARTICULAR PURPOSE. Please see the CERN-OHL-W v2 for applicable conditions. 

Source location: https://github.com/MMMZZZZ/WiFi-SD-Adapter

As per CERN-OHL-W v2 section 4.1, should You produce hardware based on these sources, You must maintain the Source Location visible on the external case of the WiFi SD Adapter or other product you make using this documentation.

## KiCad design WiFi-SD-Adapter.kicad_pcb

Board: 6 copper layers, 32.0 x 24.0 mm, 38 parts (4 on the bottom side), 42 nets.

Parts:
ANT1: 2450AT18A100E
C1, C2: 10p; C_0603_1608Metric
C3, C5, C6, C8, C10, C11, C12: 100n; C_0603_1608Metric
C7: 10u; C_0603_1608Metric
C13: 1p5; C_0402_1005Metric
D1: LED_ESP; LED_0603_1608Metric
D2: LED_CAR; LED_0603_1608Metric
J2: SD_Card
J3: USB_C_Receptacle_USB2.0; USB_C_PCB_Single-Side
J5: Micro_SD_Card; microSD_Card
JP1: Reset; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: ESP_Power_Select; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: Boot; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1, L2: 2n2; L_0603_1608Metric
L3, L4: 2n2; L_0402_1005Metric
R1, R6: 1k; R_0603_1608Metric
R3, R5, R7, R8, R9: 5k1; R_0603_1608Metric
R4: 12; R_0603_1608Metric
U3: ESP32-C3; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm
Y1: Crystal_40MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm
locked: 503398-1892
locked#2, locked#4: ADG3245BCPZ; QFN50P400X400X80-21N-D
locked#3: AP7331-33SNG-7; AP733133SNG7

Connections:
+3.3V: C5.1, C7.1, C8.1, J5.4 (VDD), JP2.2 (C), L1.1, R1.2, R5.2, R6.2, R7.2, R8.2, R9.2, U3.11 (VDD3P3_RTC), U3.17 (VDD3P3_CPU), U3.18 (VDD_SPI/GPIO11), U3.31 (VDDA), U3.32 (VDDA), locked.4 (VDD), locked#2.1 (~SEL), locked#2.16 (VCC), locked#4.1 (~SEL), locked#4.16 (VCC)
+5V: C11.1, L2.2, locked#3.1 (EN), locked#3.3 (IN)
/3V3_RF: C6.1, L1.2, U3.2 (VDD3P3), U3.3 (VDD3P3)
/3V3_SD_IN: J2.4 (VDD), JP2.3 (B)
/3V3_USB_IN: JP2.1 (A), locked#3.4 (OUT)
/BOOT: C12.1, JP3.2 (B), R7.1, U3.15 (GPIO9/BOOT)
/CS: U3.13 (MTDO/GPIO7), locked#4.2 (A4)
/DAT1: U3.28 (U0TXD/GPIO21), locked#4.19 (A2)
/DAT2: U3.27 (U0RXD/GPIO20), locked#4.20 (A3)
/MISO: U3.10 (MTDI/GPIO5/ADC2_CH0), locked#4.5 (A7)
/MOSI: U3.12 (MTCK/GPIO6), locked#4.3 (A5)
/SCLK: U3.9 (MTMS/GPIO4/ADC1_CH4), locked#4.4 (A6)
/SD_CD/DAT3: J2.1 (CD/DAT3), locked#2.13 (B1)
/SD_CLK: J2.5 (CLK), locked#2.10 (B4)
/SD_CMD: J2.2 (CMD), locked#2.11 (B3)
/SD_DAT0: J2.7 (DAT0), locked#2.9 (B5)
/SD_DAT1: J2.8 (DAT1), locked#2.8 (B6)
/SD_DAT2: J2.9 (DAT2), locked#2.14 (B0)
/USB_CC1: J3.A5 (CC1), R3.1
/USB_D+: J3.A6 (D+), U3.26 (GPIO19/USB_D+)
/USB_D-: J3.A7 (D-), U3.25 (GPIO18/USB_D-)
/USB_VBUS: C10.1, J3.A4 (VBUS), J3.A9 (VBUS), L2.1
/microSD_CD/DAT3: J5.2 (DAT3/CD), locked.2 (CD/DAT3), locked#2.18 (A1), locked#4.10 (B4)
/microSD_CLK: J5.5 (CLK), locked.5 (CLK), locked#2.2 (A4), locked#4.8 (B6)
/microSD_CMD: J5.3 (CMD), locked.3 (CMD), locked#2.20 (A3), locked#4.9 (B5)
/microSD_DAT0: J5.7 (DAT0), locked.7 (DAT0), locked#2.3 (A5), locked#4.7 (B7)
/microSD_DAT1: J5.8 (DAT1), locked.8 (DAT1), locked#2.4 (A6), locked#4.12 (B2)
/microSD_DAT2: J5.1 (DAT2), locked.1 (DAT2), locked#2.17 (A0), locked#4.11 (B3)
/~SD_CAR_ENABLE: D2.1 (K), U3.8 (GPIO3/ADC1_CH3), locked#2.15 (~BE)
/~SD_ESP_ENABLE: D1.1 (K), U3.16 (GPIO10), locked#4.15 (~BE)
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, J2.3 (VSS), J2.6 (VSS), J3.A1 (GND), J3.A12 (GND), J5.6 (VSS), JP1.1 (A), JP3.1 (A), L4.1, R3.2, U3.33 (GND), Y1.2, Y1.4, locked.6 (VSS), locked.11, locked.12, locked.13, locked#2.6 (GND), locked#2.21 (GROUND), locked#3.2 (GND_1), locked#3.7 (GND_2), locked#4.6 (GND), locked#4.21 (GROUND)
unnamed: ANT1.1 (FEED), L3.1
unnamed: C2.1, R4.2, Y1.1
unnamed: C13.1, L3.2, L4.2
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R6.1
unnamed: C3.1, JP1.2 (B), R5.1, U3.7 (CHIP_EN)
unnamed: R9.1, U3.6 (GPIO2/ADC1_CH2)
unnamed: R8.1, U3.14 (GPIO8)
unnamed: C13.2, U3.1 (LNA_IN)
unnamed: C1.1, U3.29 (XTAL_N), Y1.3
unnamed: R4.1, U3.30 (XTAL_P)

File production/WiFi_SD_Adapter_v2.3.0/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
ANT1,2450AT18A100E,1,2450AT18A100E,
"C1, C2",0603,2,10p,
"C10, C11, C12, C3, C5, C6, C8",0603,7,100n,
C13,0402,1,1p5,
C7,0603,1,10u,
D1,0603,1,LED_ESP,
D2,0603,1,LED_CAR,
"IC1, IC2",QFN50P400X400X80-21N-D,2,ADG3245BCPZ,
IC3,AP733133SNG7,1,AP7331-33SNG-7,
J2,SD_Card,1,SD_Card,
J3,USB_C_PCB_Single-Side,1,USB_C_Receptacle_USB2.0,
J4,503398-1892,1,503398-1892,
J5,microSD_Card,1,Micro_SD_Card,
JP1,SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm,1,Reset,
JP2,SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm,1,ESP_Power_Select,
JP3,SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm,1,Boot,
"L1, L2",0603,2,2n2,
"L3, L4",0402,2,2n2,
"R1, R6",0603,2,1k,
"R3, R5, R7, R8, R9",0603,5,5k1,
R4,0603,1,12,
U3,QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm,1,ESP32-C3,
Y1,Crystal_SMD_2016-4Pin_2.0x1.6mm,1,Crystal_40MHz,

## Commit log

2024-01-04 Added License: CERN OHL-W
2024-01-04 Original Version
2024-01-05 LCSC Version (v2.0.0)
    Adapted schematic and layout to the parts available on LCSC at the time of ordering.
2024-01-05 LCSC Version: Switched SD Contact Side... (v2.1.0)
    - Same fixes as v1.1.0 vs v1.0.0
    - Additionally, fixed some library structure issues. These were probably present in all previous versions due to the migration to GitHub and the restauration of previous versions.
    - Project QR code
    - Probably some more things that I've forgotten.
2024-01-05 Fixed SD Interface Placement ...
    - Fixed: SD interface needs to be on the component side.
    - Reworked the layout accordingly
    - Switched to 6-layer PCB (besides the much tighter space, it's currently cheap on JLC)
    - Fixed: Boot/Reset pullup was miswired.
2024-01-06 Meaningful Names for Screenshots and iBom
2024-01-06 Followed CERN-OHL-W v2 HowTo
2024-01-06 Fixed Screenshots
2024-01-06 Fixed iBom Link
2024-01-06 Mouser Parts Licensing
2024-01-07 Smaller Pictures
2024-01-12 ESP32 Pinout Fixes
    Had stuff connected to the flash SPI pins which cannot be used even if the flash is integrated into the chip.
2024-01-14 Fixed: Strapping Pins Pullups, Adjusted Layout
2024-01-17 Created Exported Files for v2.2.0
2024-02-06 Current State
2024-02-19 Pinout Fixes, mSD Direct Soldering Footprint

Notices in the files:
WiFi-SD-Adapter.kicad_pcb:
License: CERN-OHL-W v2 or later
